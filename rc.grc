options:
  parameters:
    author: User
    generate_options: qt_gui
    id: rc
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Custom RX Block",
                  in_sig=[np.complex64],
                  out_sig=[np.float32])

          def work(self, input_items, output_items):
              output_items[0][:] = np.abs(input_items[0])  
              return len(output_items[0])
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: RX
    args: hackrf=0
    bb_gain0: '20'
    bw0: 10e6
    freq0: freq
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 10e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 10e6
    fc: 2100e3
    fftsize: '1024'
    name: Receiver
    type: float
  states: {}

connections:
- [epy_block_0_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', epy_block_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
